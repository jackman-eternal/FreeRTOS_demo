# Keil uVision project freeRTOS_TEST.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\cmsis;..\Fwlib\inc;..\user;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\system\delay;..\system\sys;..\system\usart;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../user/: main.c led.c timer.c
  group CMSIS
    ../cmsis/: core_cm3.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h startup_stm32f10x_md.s
  group FWLIB
    ../Fwlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group SYSTEM
    ../system/sys/: sys.c
    ../system/usart/: usart.c
    ../system/delay/: delay.c
